<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>testbb</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>gr_rds_data_encoder</key>
<param><key>id</key><value>gr_rds_data_encoder_1</value></param>
<param><key>xmlfile</key><value>/media/dimitris/mywork/gr/dimitris/rds/trunk/src/utils/rds_data.xml</value></param>
</block>
<block>
<key>gr_rds_data_decoder</key>
<param><key>id</key><value>gr_rds_data_decoder_0_0</value></param>
<param><key>msgq</key><value>gr.msg_queue()</value></param>
</block>
<block>
<key>gr_head</key>
<param><key>id</key><value>gr_head_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>num_items</key><value>1040</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_add_xx</key>
<param><key>id</key><value>gr_add_xx_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>audio_source</key>
<param><key>id</key><value>audio_source_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>samp_rate</key><value>16000</value></param>
<param><key>device_name</key><value>plughw:0,0</value></param>
</block>
<block>
<key>gr_char_to_float</key>
<param><key>id</key><value>gr_char_to_float_1</value></param>
<param><key>_enabled</key><value>False</value></param>
</block>
<block>
<key>gr_null_sink</key>
<param><key>id</key><value>gr_null_sink_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<connection><source_block_id>gr_rds_data_encoder_1</source_block_id><sink_block_id>gr_char_to_float_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_rds_data_encoder_1</source_block_id><sink_block_id>gr_head_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_head_0</source_block_id><sink_block_id>gr_rds_data_decoder_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>audio_source_0_0</source_block_id><sink_block_id>gr_add_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>gr_char_to_float_1</source_block_id><sink_block_id>gr_add_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_add_xx_0_0</source_block_id><sink_block_id>gr_null_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
